# Keil uVision project sdram.uvproj, settings and files
target FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: s_sdram +hex
  c flags: Optim=1 wLevel=1
  c define: TEST_JUMPING
  c include: ..\..\libs\Lib_CMSIS\inc;..\..\libs\Lib_MCU\inc;..\..\libs\Lib_OemBoard\inc;..\..\libs\Lib_LPC\inc;..\..\libs\Lib_OemBaseBoard\inc;..\src\Protocols;..\src;..\..\s_sdram;..\..\
  asm define: NO_CRP
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0xa2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Config\FLASH\s_sdram.sct
  group Lib_CMSIS
    ../../libs/Lib_CMSIS/src/: system_LPC177x_8x.c
  group Lib_MCU
    ../../libs/Lib_MCU/src/: lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_timer.c lpc177x_8x_crc.c lpc177x_8x_eeprom.c lpc177x_8x_rtc.c lpc177x_8x_can.c lpc177x_8x_gpio.c debug_frmwrk.c lpc177x_8x_mci.c lpc177x_8x_gpdma.c lpc177x_8x_ssp.c lpc177x_8x_nvic.c lpc177x_8x_wwdt.c
  group Lib_OemBoard
    ../../libs/Lib_OemBoard/src/: sdram.c
  group Lib_OemBaseBoard
    ../../libs/Lib_OemBaseBoard/src/: board.c fs_diskio.c fs_ff.c
    ../../libs/Lib_OemBoard/src/: nand.c
  group Source Code
    ../src/: main.c delay.c generalFunction.c RelayController.c Uart_Helper.c ErrHandling.c spi_helper.c sdcard.c log_Helper.c crc_calc.c BT_Helper.c EEPROMManage.c blowfish.c lib_crc.c
    ../../libs/c_keil_uvision/: startup_LPC177x_8x.s
  group ECU
    ../src/: ECU_helper.c
    ../../: ECU.c
  group AESCRC
    ../src/: CRCGenerator.c decode.c encode.c
  group Protocols
    ../src/Protocols/: Protocol_KWP.c Protocol_CAN.c Protocol_Rio.c Protocol_SL96.c Protocol_x2000.c
  group Interrupts
    ../src/: Uart_InterruptManager.c Uart_InterruptManager_1.c Uart_InterruptManager_2.c
  group Comm
    ../src/: CarCommProtocol.c CommProtocol.c
  group Security
    ../src/: SecurityLevels.c
target RAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: s_sdram +hex
  c flags: Optim=2 wLevel=1
  c define: __RAM_MODE__,RELEASE_CODE,__NO_SDRAM__
  c include: ..\..\libs\Lib_CMSIS\inc;..\..\libs\Lib_MCU\inc;..\..\libs\Lib_OemBoard\inc;..\..\libs\Lib_LPC\inc;..\..\libs\Lib_OemBaseBoard\inc;..\src\Protocols;..\src;..\..\
  asm define: NO_CRP
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0xa2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Config\RAM\s_sdram.sct
target RAM_TEST (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: s_sdram +hex
  c flags: Optim=2 wLevel=1
  c define: TEST_JUMPING,RAM_TEST
  c include: as above
  asm define: NO_CRP
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0xa2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Config\RAM\s_sdram.sct
